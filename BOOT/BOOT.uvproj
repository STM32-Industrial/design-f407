# Keil uVision project BOOT.uvproj, settings and files
target BOOT (6070000::V6.7::.\ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: BOOT +hex
  c flags: Optim=3 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: -std=gnu11 -Oz
  c include: ..\CORE;..\USER;..\FWLIB\inc;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group BOOT
    ./: main.c boot_flash.c boot_uart.c crc32.c
  group SYSTEM
    ../USER/: system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_iwdg.c
