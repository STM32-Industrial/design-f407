# Keil uVision project LED.uvproj, settings and files
target LED (6070000::V6.7::.\ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: LED +hex
  c flags: Optim=3 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: -std=gnu11 -Oz
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\PWM;..\HARDWARE\ESP8266;..\HARDWARE\LCD;..\HARDWARE\CAN;..\HARDWARE\TOUCH;..\HARDWARE\FreeRTOS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\HARDWARE\LVGL;..\HARDWARE\LVGL\src;..\HARDWARE\LVGL\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/TOUCH/: touch.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FreeRTOS
    ../FreeRTOS/Source/: tasks.c queue.c list.c timers.c event_groups.c croutine.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_can.c
  group LVGL_core
    ../HARDWARE/LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
  group LVGL_debugging
    ../HARDWARE/LVGL/src/debugging/monkey/: lv_monkey.c
    ../HARDWARE/LVGL/src/debugging/sysmon/: lv_sysmon.c
    ../HARDWARE/LVGL/src/debugging/test/: lv_test_display.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../HARDWARE/LVGL/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
  group LVGL_display
    ../HARDWARE/LVGL/src/display/: lv_display.c
  group LVGL_draw
    ../HARDWARE/LVGL/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../HARDWARE/LVGL/src/draw/convert/: lv_draw_buf_convert.c
    ../HARDWARE/LVGL/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../HARDWARE/LVGL/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../HARDWARE/LVGL/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../HARDWARE/LVGL/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../HARDWARE/LVGL/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../HARDWARE/LVGL/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    ../HARDWARE/LVGL/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../HARDWARE/LVGL/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../HARDWARE/LVGL/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../HARDWARE/LVGL/src/draw/opengles/: lv_draw_opengles.c
    ../HARDWARE/LVGL/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../HARDWARE/LVGL/src/draw/sdl/: lv_draw_sdl.c
    ../HARDWARE/LVGL/src/draw/snapshot/: lv_snapshot.c
    ../HARDWARE/LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../HARDWARE/LVGL/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../HARDWARE/LVGL/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../HARDWARE/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../HARDWARE/LVGL/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group LVGL_drivers
    ../HARDWARE/LVGL/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ../HARDWARE/LVGL/src/drivers/display/fb/: lv_linux_fbdev.c
    ../HARDWARE/LVGL/src/drivers/display/ft81x/: lv_ft81x.c
    ../HARDWARE/LVGL/src/drivers/display/ili9341/: lv_ili9341.c
    ../HARDWARE/LVGL/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../HARDWARE/LVGL/src/drivers/display/nv3007/: lv_nv3007.c
    ../HARDWARE/LVGL/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../HARDWARE/LVGL/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../HARDWARE/LVGL/src/drivers/display/st7735/: lv_st7735.c
    ../HARDWARE/LVGL/src/drivers/display/st7789/: lv_st7789.c
    ../HARDWARE/LVGL/src/drivers/display/st7796/: lv_st7796.c
    ../HARDWARE/LVGL/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../HARDWARE/LVGL/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../HARDWARE/LVGL/src/drivers/evdev/: lv_evdev.c
    ../HARDWARE/LVGL/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../HARDWARE/LVGL/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../HARDWARE/LVGL/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../HARDWARE/LVGL/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
    ../HARDWARE/LVGL/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    ../HARDWARE/LVGL/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../HARDWARE/LVGL/src/drivers/qnx/: lv_qnx.c
    ../HARDWARE/LVGL/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
    ../HARDWARE/LVGL/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../HARDWARE/LVGL/src/drivers/wayland/: lv_wayland.c lv_wl_egl_backend.c lv_wl_g2d_backend.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_seat.c lv_wl_shm_backend.c lv_wl_touch.c lv_wl_window.c lv_wl_xdg_shell.c
    ../HARDWARE/LVGL/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../HARDWARE/LVGL/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
  group LVGL_font
    ../HARDWARE/LVGL/src/font/binfont_loader/: lv_binfont_loader.c
    ../HARDWARE/LVGL/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../HARDWARE/LVGL/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../HARDWARE/LVGL/src/font/imgfont/: lv_imgfont.c
    ../HARDWARE/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group LVGL_indev
    ../HARDWARE/LVGL/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group LVGL_layouts
    ../HARDWARE/LVGL/src/layouts/flex/: lv_flex.c
    ../HARDWARE/LVGL/src/layouts/grid/: lv_grid.c
    ../HARDWARE/LVGL/src/layouts/: lv_layout.c
  group LVGL_libs
    ../HARDWARE/LVGL/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../HARDWARE/LVGL/src/libs/barcode/: code128.c lv_barcode.c
    ../HARDWARE/LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ../HARDWARE/LVGL/src/libs/bmp/: lv_bmp.c
    ../HARDWARE/LVGL/src/libs/ffmpeg/: lv_ffmpeg.c
    ../HARDWARE/LVGL/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../HARDWARE/LVGL/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../HARDWARE/LVGL/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../HARDWARE/LVGL/src/libs/gif/: gif.c
    ../HARDWARE/LVGL/src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
    ../HARDWARE/LVGL/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../HARDWARE/LVGL/src/libs/gltf/math/: lv_3dmath.c
    ../HARDWARE/LVGL/src/libs/gstreamer/: lv_gstreamer.c
    ../HARDWARE/LVGL/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../HARDWARE/LVGL/src/libs/libpng/: lv_libpng.c
    ../HARDWARE/LVGL/src/libs/libwebp/: lv_libwebp.c
    ../HARDWARE/LVGL/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../HARDWARE/LVGL/src/libs/lz4/: lz4.c
    ../HARDWARE/LVGL/src/libs/nanovg/: nanovg.c
    ../HARDWARE/LVGL/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../HARDWARE/LVGL/src/libs/rle/: lv_rle.c
    ../HARDWARE/LVGL/src/libs/rlottie/: lv_rlottie.c
    ../HARDWARE/LVGL/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../HARDWARE/LVGL/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../HARDWARE/LVGL/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../HARDWARE/LVGL/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../HARDWARE/LVGL/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../HARDWARE/LVGL/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
  group LVGL_lv_init.c
    ../HARDWARE/LVGL/src/: lv_init.c
  group LVGL_misc
    ../HARDWARE/LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../HARDWARE/LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../HARDWARE/LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../HARDWARE/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group LVGL_osal
    ../HARDWARE/LVGL/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group LVGL_others
    ../HARDWARE/LVGL/src/others/file_explorer/: lv_file_explorer.c
    ../HARDWARE/LVGL/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../HARDWARE/LVGL/src/others/translation/: lv_translation.c
  group LVGL_stdlib
    ../HARDWARE/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../HARDWARE/LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../HARDWARE/LVGL/src/stdlib/: lv_mem.c
    ../HARDWARE/LVGL/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../HARDWARE/LVGL/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../HARDWARE/LVGL/src/stdlib/uefi/: lv_mem_core_uefi.c
  group LVGL_themes
    ../HARDWARE/LVGL/src/themes/default/: lv_theme_default.c
    ../HARDWARE/LVGL/src/themes/: lv_theme.c
    ../HARDWARE/LVGL/src/themes/mono/: lv_theme_mono.c
    ../HARDWARE/LVGL/src/themes/simple/: lv_theme_simple.c
  group LVGL_tick
    ../HARDWARE/LVGL/src/tick/: lv_tick.c
  group LVGL_widgets
    ../HARDWARE/LVGL/src/widgets/3dtexture/: lv_3dtexture.c
    ../HARDWARE/LVGL/src/widgets/animimage/: lv_animimage.c
    ../HARDWARE/LVGL/src/widgets/arc/: lv_arc.c
    ../HARDWARE/LVGL/src/widgets/arclabel/: lv_arclabel.c
    ../HARDWARE/LVGL/src/widgets/bar/: lv_bar.c
    ../HARDWARE/LVGL/src/widgets/button/: lv_button.c
    ../HARDWARE/LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../HARDWARE/LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../HARDWARE/LVGL/src/widgets/canvas/: lv_canvas.c
    ../HARDWARE/LVGL/src/widgets/chart/: lv_chart.c
    ../HARDWARE/LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../HARDWARE/LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../HARDWARE/LVGL/src/widgets/gif/: lv_gif.c
    ../HARDWARE/LVGL/src/widgets/image/: lv_image.c
    ../HARDWARE/LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ../HARDWARE/LVGL/src/widgets/ime/: lv_ime_pinyin.c
    ../HARDWARE/LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../HARDWARE/LVGL/src/widgets/label/: lv_label.c
    ../HARDWARE/LVGL/src/widgets/led/: lv_led.c
    ../HARDWARE/LVGL/src/widgets/line/: lv_line.c
    ../HARDWARE/LVGL/src/widgets/list/: lv_list.c
    ../HARDWARE/LVGL/src/widgets/lottie/: lv_lottie.c
    ../HARDWARE/LVGL/src/widgets/menu/: lv_menu.c
    ../HARDWARE/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../HARDWARE/LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../HARDWARE/LVGL/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../HARDWARE/LVGL/src/widgets/roller/: lv_roller.c
    ../HARDWARE/LVGL/src/widgets/scale/: lv_scale.c
    ../HARDWARE/LVGL/src/widgets/slider/: lv_slider.c
    ../HARDWARE/LVGL/src/widgets/span/: lv_span.c
    ../HARDWARE/LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../HARDWARE/LVGL/src/widgets/spinner/: lv_spinner.c
    ../HARDWARE/LVGL/src/widgets/switch/: lv_switch.c
    ../HARDWARE/LVGL/src/widgets/table/: lv_table.c
    ../HARDWARE/LVGL/src/widgets/tabview/: lv_tabview.c
    ../HARDWARE/LVGL/src/widgets/textarea/: lv_textarea.c
    ../HARDWARE/LVGL/src/widgets/tileview/: lv_tileview.c
    ../HARDWARE/LVGL/src/widgets/win/: lv_win.c
  group LVGL_Port
    ../HARDWARE/LVGL/port/: lv_port.c ui.c
